inherit pypi setuptools
require python-psutil.inc

RDEPENDS_${PN} += " \
    python-subprocess \
"
