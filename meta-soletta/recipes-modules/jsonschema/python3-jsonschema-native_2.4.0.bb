require python3-jsonschema.inc
inherit native

DEPENDS += " python3-native"
