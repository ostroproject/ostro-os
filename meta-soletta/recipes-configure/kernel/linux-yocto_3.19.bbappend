FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://pwm.cfg \
            file://ath9k_htc.cfg"
