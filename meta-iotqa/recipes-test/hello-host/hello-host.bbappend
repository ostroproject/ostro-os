inherit deploy-files
DEPLOY_FILES_FROM[native] = "${WORKDIR}/hello"
