inherit deploy-files
DEPLOY_FILES_FROM[target] = "${WORKDIR}/hello_mraa"
