inherit deploy-files
DEPLOY_FILES_FROM[target] = "${B}/systemd-analyze"
