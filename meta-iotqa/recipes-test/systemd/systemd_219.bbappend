inherit copybin
TARGET_FILES += "${WORKDIR}/build/systemd-analyze"
