inherit deploy-files
DEPLOY_FILES_FROM[target] = "${WORKDIR}/bluez-${PV}/attrib/gatttool"
