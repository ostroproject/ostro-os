inherit deploy-files
DEPLOY_FILES_FROM[target] = "${WORKDIR}/test_get_sensor_type_by_id ${WORKDIR}/test_connect_sensor_already_connected ${WORKDIR}/test_get_all_installed_sensor_count ${WORKDIR}/test_get_sensor_count_by_type ${WORKDIR}/test_get_all_installed_sensor ${WORKDIR}/test_get_sensor_list_by_type ${WORKDIR}/test_get_sensor_by_id ${WORKDIR}/test_get_default_sensor_by_type ${WORKDIR}/test_get_sensor_status_by_id ${WORKDIR}/test_disconnect_sensor_invalid_id ${WORKDIR}/test_disconnect_unconnected_sensor ${WORKDIR}/test_get_sensor_name_by_id ${WORKDIR}/test_get_sensor_type_list ${WORKDIR}/test_get_sensor_type_list_incorrect_count ${WORKDIR}/test_unregister_unregistered_sensor ${WORKDIR}/test_sensor_register_unregister_misc ${WORKDIR}/test_get_sensor_data_by_id ${WORKDIR}/test_set_sensor_data_by_id ${WORKDIR}/test_sensor_type_is_supported ${WORKDIR}/test_get_default_sensor_and_manipulation ${WORKDIR}/test_set_sensor_data_after_unregister ${WORKDIR}/test_sensor_register_duplicated ${WORKDIR}/test_get_sensor_raw_data_by_id ${WORKDIR}/test_sensor_framework_ready ${WORKDIR}/test_connect_sensor_maximum_times ${WORKDIR}/test_stress_connect_disconnect_sensor ${WORKDIR}/test_stress_set_get_data_of_sensor ${WORKDIR}/test_get_data_of_unconnected_sensor"
