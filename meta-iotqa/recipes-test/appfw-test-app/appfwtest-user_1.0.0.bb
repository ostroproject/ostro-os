DESCRIPTION = "User of AppFW Test App"
IOT_USER_NAME = "appfwtest"
IOT_USER_SHELL = "/bin/bash"
inherit iot-user
