FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

# This policy file will get installed as /etc/ima/ima-policy in
# the initramfs.
IMA_POLICY = "ima_policy_ostro"
