# remove runtime dependensies to libx, as X is not included in the image
RDEPENDS_remove = " libxrender-native libxrender" 
