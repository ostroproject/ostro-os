SUMMARY = "Soletta IoT Framework"
LICENSE = "MIT"

inherit packagegroup

RDEPENDS_${PN} = " \
    soletta \
"
