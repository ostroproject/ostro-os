openjdk-8_%.bbappend