FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append_quark = " file://0001-Add-momit_lock_prefix-no-yes-option.patch"
