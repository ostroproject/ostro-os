FILESEXTRAPATHS_prepend := "${THISDIR}/u-boot:"

SRC_URI_append = " file://0001-Search-for-bootable-partitions-on-both-SD-and-eMMC.patch"
