IMAGE_ROOTFS_EXTRA_SPACE_edison = "0"
IMAGE_INSTALL_append_edison = " \
		bluetooth-rfkill-event \
		bcm43340-bt \
		bcm43340-fw \
		bcm43340-mod \
		"
