require ../../conf/machine/include/edison-image-config.inc
