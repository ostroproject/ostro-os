EXTRA_OECONF_append_quark = " --disable-aesni-support \
                              --disable-padlock-support"
