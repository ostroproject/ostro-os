FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append_quark = " file://quark.patch"
