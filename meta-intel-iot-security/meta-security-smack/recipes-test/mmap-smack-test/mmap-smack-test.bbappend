inherit deploy-files
DEPLOY_FILES_FROM[target] = "${WORKDIR}/mmap_test"
