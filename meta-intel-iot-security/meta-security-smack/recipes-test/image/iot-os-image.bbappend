EXTRA_IMAGEDEPENDS += "mmap-smack-test  tcp-smack-test  udp-smack-test"
