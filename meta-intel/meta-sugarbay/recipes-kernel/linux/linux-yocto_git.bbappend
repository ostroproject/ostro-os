FILESEXTRAPATHS := "${THISDIR}/${PN}"

COMPATIBLE_MACHINE_sugarbay = "sugarbay"
KMACHINE_sugarbay  = "yocto/standard/sugarbay"

