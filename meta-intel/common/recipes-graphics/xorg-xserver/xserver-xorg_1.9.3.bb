require recipes-graphics/xorg-xserver/xserver-xorg.inc
require xserver-xorg-${PV}.inc

PE = "1"
