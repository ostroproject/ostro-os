require libva.inc

PR = "${INC_PR}.0"

SRC_URI = "http://cgit.freedesktop.org/libva/snapshot/libva-${PV}.tar.bz2"

SRC_URI[md5sum] = "84408a0746a63b8cf308dc7b9f2451cf"
SRC_URI[sha256sum] = "e80aae68fc78d237d046be6525d333f072fd57fe4f4d8f981e869703ebfee8f5"
