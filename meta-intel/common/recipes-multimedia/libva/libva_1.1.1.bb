require libva.inc

PR = "${INC_PR}.0"

SRC_URI = "http://www.freedesktop.org/software/vaapi/releases/libva/libva-${PV}.tar.bz2"

SRC_URI[md5sum] = "cd5cc1ce37d6fc6f991ef579ac81d891"
SRC_URI[sha256sum] = "c0af7bf3e96e19fbd0513fbf461a010638907136b5ee0d68094fa0cc7e66cd4d"
