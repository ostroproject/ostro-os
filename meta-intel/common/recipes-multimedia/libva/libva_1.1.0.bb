require libva.inc

PR = "${INC_PR}.0"

SRC_URI = "http://www.freedesktop.org/software/vaapi/releases/libva/libva-${PV}.tar.bz2"

SRC_URI[md5sum] = "51bb3b8de1de14ea036f68ef5065a932"
SRC_URI[sha256sum] = "db6adc24a6f02f234a823dd8ced4a7e38084581f4ae02b6aac10716e523cefa8"
