require libva.inc

PR = "${INC_PR}.0"

SRC_URI = "http://cgit.freedesktop.org/vaapi/libva/snapshot/libva-${PV}.tar.bz2"

SRC_URI[md5sum] = "ad8a94ba87ff0563a533c3c142816794"
SRC_URI[sha256sum] = "7cc24ae9c947aa13904255244810d3637b03d41e2b6f4b643db3b97412cacd37"
