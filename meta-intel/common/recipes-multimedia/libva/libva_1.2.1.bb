require libva.inc

PR = "${INC_PR}.0"

SRC_URI = "http://www.freedesktop.org/software/vaapi/releases/libva/libva-${PV}.tar.bz2"

SRC_URI[md5sum] = "ca95b343050cf8feaf98dfe08ce0191b"
SRC_URI[sha256sum] = "70080f8b260ca4316f7e100f2ce15ad3e2356a2b9eff951278085ff8d48ea83b"
