require libva-intel-driver.inc

PR = "${INC_PR}.0"

SRC_URI = "http://cgit.freedesktop.org/vaapi/intel-driver/snapshot/intel-driver-${PV}.tar.bz2"

SRC_URI[md5sum] = "9dbd642f18993335146480a3a2987874"
SRC_URI[sha256sum] = "52f16f78129af00ec40afc6a1b8fb07c7b6c6c0da7f43a54e19afd2a41791098"
