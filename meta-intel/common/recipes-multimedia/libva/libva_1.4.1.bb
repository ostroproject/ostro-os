require libva.inc

SRC_URI = "http://www.freedesktop.org/software/vaapi/releases/libva/${BP}.tar.bz2"

SRC_URI[md5sum] = "8e3e7096750c14d1f98da807df7c1ba5"
SRC_URI[sha256sum] = "0662af0ecdf1cfd2bb47e86f5bf66009554fe12ce7bf5b9cec6a2cc43f3f4c11"
