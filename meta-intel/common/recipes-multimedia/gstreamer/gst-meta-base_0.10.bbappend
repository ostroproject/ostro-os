RDEPENDS_gst-meta-video += "\
    gst-plugins-good-isomp4"

RDEPENDS_gst-meta-base += "\
    gst-ffmpeg"

COMPATIBLE_MACHINE = "(crownbay|fri2)"

PR := "${PR}.0"
