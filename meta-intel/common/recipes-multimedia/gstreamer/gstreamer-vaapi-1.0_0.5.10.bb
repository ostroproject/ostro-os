require gstreamer-vaapi.inc

DEPENDS += "gstreamer1.0 gstreamer1.0-plugins-base gstreamer1.0-plugins-bad"

GST_API_VERSION = "1.4"

SRC_URI[md5sum] = "3bd90b696b644be943450ba0c1497193"
SRC_URI[sha256sum] = "0dd236c7bf225322b8934fdba99a7a9e4542566a2acbe7564cdc3ec2c8b73c9d"

