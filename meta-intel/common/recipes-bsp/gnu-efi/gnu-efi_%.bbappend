FILESEXTRAPATHS_prepend := "${THISDIR}/gnu-efi:"
SRC_URI += "file://0001-Add-GUID-for-SMBIOS-3-entry-point-structure.patch"
