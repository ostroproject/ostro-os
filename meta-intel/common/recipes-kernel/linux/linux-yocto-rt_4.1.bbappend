FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

LINUX_VERSION_core2-32-intel-common = "4.1.8"
COMPATIBLE_MACHINE_core2-32-intel-common = "${MACHINE}"
SRCREV_meta_core2-32-intel-common = "3d8f1378d07dbc052ca8a7c22297339ad7998b5e"
SRCREV_machine_core2-32-intel-common = "29257e529f968d17a5238624f27ddc76f759dc9d"
KMACHINE_core2-32-intel-common = "intel-core2-32"
KBRANCH_core2-32-intel-common = "standard/preempt-rt/base"
KERNEL_FEATURES_append_core2-32-intel-common = "${KERNEL_FEATURES_INTEL_COMMON}"

LINUX_VERSION_corei7-64-intel-common = "4.1.8"
COMPATIBLE_MACHINE_corei7-64-intel-common = "${MACHINE}"
SRCREV_meta_corei7-64-intel-common = "3d8f1378d07dbc052ca8a7c22297339ad7998b5e"
SRCREV_machine_corei7-64-intel-common = "29257e529f968d17a5238624f27ddc76f759dc9d"
KMACHINE_corei7-64-intel-common = "intel-corei7-64"
KBRANCH_corei7-64-intel-common = "standard/preempt-rt/base"
KERNEL_FEATURES_append_corei7-64-intel-common = "${KERNEL_FEATURES_INTEL_COMMON}"
