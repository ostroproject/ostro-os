FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRCREV = "62080b2248fd8ec4111ffc379d0bc5eaf0a5c16d"

#SRC_URI = "git://git.lttng.org/lttng-modules.git;branch=stable-2.6 \
#           file://lttng-modules-replace-KERNELDIR-with-KERNEL_SRC.patch \
#           "


