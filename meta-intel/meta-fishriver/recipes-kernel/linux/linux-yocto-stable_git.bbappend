FILESEXTRAPATHS := "${FILESEXTRAPATHS}:${THISDIR}/${PN}"

COMPATIBLE_MACHINE_fishriver = "crownbay"
KMACHINE_fishriver  = "crownbay"

