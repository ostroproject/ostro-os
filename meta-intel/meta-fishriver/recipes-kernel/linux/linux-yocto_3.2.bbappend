FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

COMPATIBLE_MACHINE_fishriver = "fishriver"
KMACHINE_fishriver  = "fishriver"
KBRANCH_fishriver  = "standard/default/fishriver"

SRCREV_machine_pn-linux-yocto_fishriver ?= "969edd015a46eed77d6c3daeffdc299dd06e3397"
SRCREV_meta_pn-linux-yocto_fishriver ?= "5b4c9dc78b5ae607173cc3ddab9bce1b5f78129b"
