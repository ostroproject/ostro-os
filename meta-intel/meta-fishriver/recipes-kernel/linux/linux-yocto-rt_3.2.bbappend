FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE_fishriver = "fishriver"
KMACHINE_fishriver  = "fishriver"

# Update the following to use a different BSP branch or meta SRCREV
#KBRANCH_fishriver  = "standard/preempt-rt/base"
#SRCREV_machine_pn-linux-yocto-rt_fishriver ?= XXXX
#SRCREV_meta_pn-linux-yocto-rt_fishriver ?= XXXX
