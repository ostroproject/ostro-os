FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

COMPATIBLE_MACHINE_fishriver = "fishriver"
KMACHINE_fishriver  = "fishriver"

SRCREV_machine_pn-linux-yocto-stable_fishriver ?= "56fe215d3f1a2cc3a5a26482ac9809ba44495695"
SRCREV_meta_pn-linux-yocto-stable_fishriver ?= "ec26387cb168e9e0976999b528b5a9dd62e3157a"
