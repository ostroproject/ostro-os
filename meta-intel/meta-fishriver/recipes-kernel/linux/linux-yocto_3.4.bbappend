FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

COMPATIBLE_MACHINE_fishriver = "fishriver"
KMACHINE_fishriver  = "fishriver"
KBRANCH_fishriver  = "standard/fishriver"

SRCREV_machine_pn-linux-yocto_fishriver ?= "49f1599b2ce0288599805b5364b895f5a9febb3e"
SRCREV_meta_pn-linux-yocto_fishriver ?= "a8cf77018b0faa0d29f1483ff4e5a2034dc8edd5"
