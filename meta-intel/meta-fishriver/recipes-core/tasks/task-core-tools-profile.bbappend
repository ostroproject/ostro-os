RRECOMMENDS_task-core-tools-profile_append_fishriver = " systemtap"

