RRECOMMENDS_task-core-tools-profile_append_chiefriver = " systemtap"

