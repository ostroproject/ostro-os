#-fomit-frame-pointer in default FULL_OPTIMIZATION will cause matchbox-panel segfault on n450
FULL_OPTIMIZATION_n450 = "-fexpensive-optimizations -frename-registers -O2 -ggdb -feliminate-unused-debug-types"
