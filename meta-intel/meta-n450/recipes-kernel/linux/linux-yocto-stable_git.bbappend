FILESEXTRAPATHS := "${THISDIR}/${PN}"
WRMACHINE_n450 = "atom-pc"
COMPATIBLE_MACHINE_n450 = "n450"

SRCREV="${AUTOREV}"
# Functionality flags
#KERNEL_REVISION_CHECKING ?= "t"
