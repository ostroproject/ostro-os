FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

COMPATIBLE_MACHINE_n450 = "n450"
KMACHINE_n450  = "atom-pc"
KBRANCH_n450 = "standard/common-pc/atom-pc"

#SRCREV_machine_pn-linux-yocto_n450 = XXXX
#SRCREV_meta_pn-linux-yocto_n450 ?= XXXX
