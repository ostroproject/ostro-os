FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE_emenlow = "emenlow"
KMACHINE_emenlow  = "emenlow"

SRCREV_machine_pn-linux-yocto_emenlow = "a29743c0a1398798fbc02c0799c8605d91514e14"
SRCREV_meta_pn-linux-yocto_emenlow ?= "ec26387cb168e9e0976999b528b5a9dd62e3157a"
