FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE_emenlow = "emenlow"
KMACHINE_emenlow  = "yocto/standard/emenlow"

SRCREV_machine_pn-linux-yocto_emenlow = "1afee6bc0496b7d528d97d7bc1585f3af7311abb"
SRCREV_meta_pn-linux-yocto_emenlow ?= "aeea99683c7283f1f3320bf2ee7085ee252d4e7e"
