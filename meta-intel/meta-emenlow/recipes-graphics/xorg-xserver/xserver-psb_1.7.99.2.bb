require recipes-graphics/xorg-xserver/xserver-xorg.inc
require xserver-psb-${PV}.inc

PE = "1"
