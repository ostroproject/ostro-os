FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

PR := "${PR}.2"
