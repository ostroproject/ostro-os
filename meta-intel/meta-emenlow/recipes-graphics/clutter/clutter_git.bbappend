DEPENDS_emenlow = "${STDDEPENDS} virtual/xserver-xf86 virtual/libgl"
EXTRA_OECONF_emenlow = "${BASE_CONF} --with-flavour=glx"
PACKAGE_ARCH_emenlow = "${MACHINE_ARCH}"

