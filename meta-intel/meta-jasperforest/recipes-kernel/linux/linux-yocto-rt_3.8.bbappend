FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

COMPATIBLE_MACHINE_jasperforest = "jasperforest"
KMACHINE_jasperforest  = "jasperforest"

# Update the following to use a different BSP branch or meta SRCREV
#KBRANCH_jasperforest  = "standard/preempt-rt/base"
#SRCREV_machine_pn-linux-yocto-rt_jasperforest ?= "XXX"
#SRCREV_meta_pn-linux-yocto-rt_jasperforest ?= "XXX"
