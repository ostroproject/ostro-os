FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

COMPATIBLE_MACHINE_jasperforest = "jasperforest"

KMACHINE_jasperforest = "jasperforest"
KBRANCH_jasperforest = "standard/common-pc-64/jasperforest"

LINUX_VERSION = "3.10.17"

SRCREV_meta_jasperforest = "f1c9080cd27f99700fa59b5375d1ddd0afe625ad"
SRCREV_machine_jasperforest = "c03195ed6e3066494e3fb4be69154a57066e845b"
