FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

COMPATIBLE_MACHINE_jasperforest = "jasperforest"

KMACHINE_jasperforest = "jasperforest"
KBRANCH_jasperforest = "standard/common-pc-64/jasperforest"

LINUX_VERSION = "3.8.4"

SRCREV_meta_jasperforest = "2a6d36e75ca0a121570a389d7bab76ec240cbfda"
SRCREV_machine_jasperforest = "47aed0c17c1c55988198ad39f86ae88894c8e0a4"
