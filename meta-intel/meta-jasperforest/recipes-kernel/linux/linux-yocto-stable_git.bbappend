FILESEXTRAPATHS := "${THISDIR}/${PN}"

COMPATIBLE_MACHINE_jasperforest = "jasperforest"
KMACHINE_jasperforest  = "jasperforest"

