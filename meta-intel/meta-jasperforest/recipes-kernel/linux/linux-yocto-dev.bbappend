FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

COMPATIBLE_MACHINE_jasperforest = "jasperforest"

KMACHINE_jasperforest = "jasperforest"
KBRANCH_jasperforest = "standard/common-pc-64/jasperforest"

SRCREV_machine_jasperforest = "60536206ad300ccf5b2be2c2d449f4ab27170238"
SRCREV_meta_jasperforest = "fe20c99783387dab779472ff50a88666da1c6391"
