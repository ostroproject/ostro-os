FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"


COMPATIBLE_MACHINE_fri2 = "fri2"
KMACHINE_fri2 = "fri2"
KBRANCH_fri2 = "standard/tiny/base"
#SRCREV_machine_pn-linux-yocto-tiny_fri2 ?= "XXX"
#SRCREV_meta_pn-linux-yocto-tiny_fri2 ?= "XXX"


COMPATIBLE_MACHINE_fri2-noemgd = "fri2-noemgd"
KMACHINE_fri2-noemgd = "fri2"
KBRANCH_fri2-noemgd = "standard/tiny/base"
#SRCREV_machine_pn-linux-yocto-tiny_fri2-noemgd ?= "XXX"
#SRCREV_meta_pn-linux-yocto-tiny_fri2-noemgd ?= "XXX"
