RRECOMMENDS_task-core-tools-profile_append_fri2 = " systemtap"
RRECOMMENDS_task-core-tools-profile_append_fri2-noemgd = " systemtap"

