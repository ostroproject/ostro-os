FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
 
PRINC := "${@int(PRINC) + 2}"
