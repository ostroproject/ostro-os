FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE_romley = "romley"
KMACHINE_romley  = "romley"

# Update the following to use a different BSP branch or meta SRCREV
#KBRANCH_romley  = "standard/preempt-rt/base"
#SRCREV_machine_pn-linux-yocto-rt_romley ?= XXXX
#SRCREV_meta_pn-linux-yocto-rt_romley ?= XXXX
