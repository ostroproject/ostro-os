DESCRIPTION = "Create iodine application provider (ie. user) with TLM session"
IOT_USER_NAME = "iodine"

inherit iot-tlmuser
