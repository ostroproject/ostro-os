DESCRIPTION = "Create yoyodine application provider (ie. user)"
IOT_USER_NAME = "yoyodine"
IOT_USER_SHELL = "/bin/bash"

inherit iot-user
