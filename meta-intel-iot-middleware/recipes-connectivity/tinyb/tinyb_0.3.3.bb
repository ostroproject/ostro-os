require tinyb.inc

SRC_URI = "git://github.com/intel-iot-devkit/tinyb.git;protocol=git;rev=2f0c16965544fa9c46c3e0f8655250f3de29b586 \
           file://0001-Fix-incorrect-pointer-in-read_value-get_value.patch \          
          "
