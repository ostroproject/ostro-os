require mraa.inc

SRC_URI = "git://github.com/intel-iot-devkit/mraa.git;protocol=git;rev=70600dece4138b0c0dbaff42f57828f1559cd840"
