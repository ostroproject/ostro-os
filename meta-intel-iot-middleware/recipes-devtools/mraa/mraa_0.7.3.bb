require mraa.inc

SRC_URI = "git://github.com/intel-iot-devkit/mraa.git;protocol=git;rev=7a2408766c9316ba74a1360aa3610fa23785f721 \
           file://0001-mraa-add-internal-mraa_find_i2c_bus-function.patch"
