require mraa.inc

SRC_URI = "git://github.com/intel-iot-devkit/mraa.git;protocol=git;rev=a17e8dbd2133e27358587c54a4c4edea2b083163"
