require mraa.inc

SRC_URI = "git://github.com/intel-iot-devkit/mraa.git;protocol=git;rev=a9429204e38416e04edbc1a6b5fe6ba49379493d"
