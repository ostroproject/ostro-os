require mraa.inc

SRC_URI = "git://github.com/intel-iot-devkit/mraa.git;protocol=git;rev=22a930e39ef0f3a38b98bad2a393b85f7042ca73"
