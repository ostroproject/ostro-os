require mraa.inc

SRC_URI = "git://github.com/intel-iot-devkit/mraa.git;protocol=git;rev=ba348a2da407ff67bb6c8c36aa0105a5458270d3"
