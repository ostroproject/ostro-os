PACKAGECONFIG ??= "eigen gtk jpeg png tiff v4l"
