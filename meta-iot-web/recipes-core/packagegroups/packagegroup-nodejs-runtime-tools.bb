SUMMARY = "Runtime tools for Node.js Apps"
LICENSE = "MIT"

inherit packagegroup

RDEPENDS_${PN} = " \
    nodejs-npm \
"
