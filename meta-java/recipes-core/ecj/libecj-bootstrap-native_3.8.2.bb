require libecj-bootstrap.inc

PR = "${INC_PR}.0"
SRC_URI = "http://archive.eclipse.org/eclipse/downloads/drops/R-3.8.2-201301310800/ecjsrc-${PV}.jar"

SRC_URI[md5sum] = "ba9d57ea2c3262e1bc2fdc42ff55e557"
SRC_URI[sha256sum] = "0474bd9964a3122e3cfe68b4c9fe370cdc24048a8ec4699d0c2f042e4990ad06"