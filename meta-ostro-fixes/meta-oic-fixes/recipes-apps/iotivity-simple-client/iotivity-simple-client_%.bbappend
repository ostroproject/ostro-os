# Upstream-Status: Submitted [directly to maintainer]

RDEPENDS_${PN}_remove = "iotivity"
RDEPENDS_${PN}_append = " iotivity-resource"
