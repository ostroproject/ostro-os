# Upstream-Status: Submitted [directly to maintainer]

DEPENDS_append = " cereal"
