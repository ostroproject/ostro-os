KBRANCH_beaglebone = "standard/beaglebone"

COMPATIBLE_MACHINE_beaglebone = "beaglebone"
