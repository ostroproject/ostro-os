# Udev is no longer a dependency for libusb, so we
# add it here until upstream fixes the dependencies.
DEPENDS_append = " udev"
