SRC_URI += "file://pam_timestamp-Avoid-leaking-file-descriptor.patch"
FILESEXTRAPATHS_prepend := "${THISDIR}/libpam:"

