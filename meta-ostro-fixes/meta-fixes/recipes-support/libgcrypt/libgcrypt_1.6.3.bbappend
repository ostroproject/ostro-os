SRC_URI += "file://0001-ecc-Free-memory-also-when-in-error-branch.patch \
            file://0002-tools-Fix-memory-leak-for-functions-I-and-G.patch \
            "
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

