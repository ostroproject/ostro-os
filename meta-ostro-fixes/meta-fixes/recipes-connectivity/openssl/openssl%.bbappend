SRC_URI += "file://0001-GH364-Free-memory-on-an-error-path.patch \
            file://0002-GH367-Fix-dsa-keygen-for-too-short-seed.patch"
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

