SRC_URI += "file://0001-gio-properly-free-memory-preventing-leak-and-illegal.patch"
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

