FILESEXTRAPATHS_prepend := "${THISDIR}/binutils:"

SRC_URI_append = " file://0013-Enable-Bsymbolic-and-Bsymbolic-functions-to-PIE.patch"
