#Upstream-Status: Pending

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Mraa-Modify-the-I2C-bus-number-for-Minnowmax-and-DE3.patch"

