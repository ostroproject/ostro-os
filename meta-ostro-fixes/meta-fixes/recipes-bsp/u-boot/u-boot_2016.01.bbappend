FILESEXTRAPATHS_prepend := "${THISDIR}/u-boot:"

SRC_URI_append = " file://0001-am335x_evm.h-unsed-CONFIG_BOOTDELAY.patch"
