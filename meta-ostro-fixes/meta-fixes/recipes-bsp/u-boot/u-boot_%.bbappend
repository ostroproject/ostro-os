SRC_URI += "file://0001-Fixes-possible-overflow-when-copying-the-string.patch"
FILESEXTRAPATHS_prepend := "${THISDIR}/u-boot:"

